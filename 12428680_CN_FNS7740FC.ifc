Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-06-21T08:33:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 08:33:18 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7ddab2cf-d1d6-4ae4-b2cb-7bc9538591d1\3c6a4799-6efb-4571-81ac-e7a9f13f1378\ifc * Database version: 5507 * Database creation date: Wed Jun 21 08:33:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 08:33:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 08:33:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12428680_CN_FNS7740FC:37774000_CN_12428680_FNS7740FC, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 37774000_CN_12428680_FNS7740FC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 37774000_CN_12428680_FNS7740FC
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1770 mm; Depth: 544 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_353594
Description: Flow; FlowDirection: SOURCEANDSINK
